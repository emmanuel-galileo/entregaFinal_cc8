# Keil uVision project ESTACION.uvprojx, settings and files
target ESTACION (6240000::V6.24::ARMCLANG)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: ESTACION +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APP_ESTACION=1
  c misc: -mrestrict-it
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./src/: main.c hw.c link.c codec.c chat_codec.c
    ./src/base/: codec.c mac.c
    ./src/third_party/heatshrink/: heatshrink_encoder.c heatshrink_decoder.c
software components: CMSIS:CORE 6.1.1, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.11.3
